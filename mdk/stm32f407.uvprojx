# Keil uVision project stm32f407.uvprojx, settings and files
target stm32f407 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: ..\app;..\app\font;..\app\page;..\app\image;..\driver\rtc;..\driver\aht20;..\driver\esp_at;..\driver\st7789;..\driver\console;..\driver\tim_delay;..\firmware\driver\inc;..\firmware\cmsis\core;..\firmware\cmsis\device;..\third_lib\freertos\include;..\third_lib\freertos\portable
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/: main.c ui.c wifi.c app.c board.c weather.c workqueue.c
  group app/font
    ../app/font/: font16.c font20.c font32.c font36.c font64.c
  group app/image
    ../app/image/: image_wifi.c image_error.c image_xiaoxing.c icon_NA.c icon_wifi.c icon_rainy.c icon_windy.c icon_sunny.c icon_snowy.c icon_cloudy.c icon_thunder.c
  group app/page
    ../app/page/: main_page.c wifi_page.c error_page.c welcome_page.c
  group driver
    ../driver/rtc/: rtc.c
    ../driver/aht20/: aht20.c
    ../driver/esp_at/: esp_at.c
    ../driver/st7789/: st7789.c
    ../driver/console/: console.c
    ../driver/tim_delay/: tim_delay.c
  group firmware/cmsis
    ../firmware/cmsis/device/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group firmware/driver
    ../firmware/driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group third_lib/freertos
    ../third_lib/freertos/: list.c tasks.c timers.c queue.c
    ../third_lib/freertos/portable/: port.c heap_4.c
